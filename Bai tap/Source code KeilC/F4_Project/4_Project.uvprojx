# Keil uVision project 4_Project.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 4_Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: .\src;..\..\..\Arm\Packs\Keil\en.stsw-stm32065_v1-9-0 (1)\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Include;..\..\..\Arm\Packs\Keil\en.stsw-stm32065_v1-9-0 (1)\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Arm\Packs\Keil\en.stsw-stm32065_v1-9-0 (1)\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Arm\Packs\Keil\en.stsw-stm32065_v1-9-0 (1)\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Arm\Packs\Keil\en.stsw-stm32065_v1-9-0 (1)\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\STM32F4xx_StdPeriph_Driver\inc\misc.h;.\kalman filter;.\Drivers;.\Sw_Drivers;.\Module
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c control_servo.c
  group startup
    ../../../Arm/Packs/Keil/en.stsw-stm32065_v1-9-0 (1)/STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group lib
    ../../../Arm/Packs/Keil/en.stsw-stm32065_v1-9-0 (1)/STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_exti.c misc.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_can.c
    ./src/: clock_demo.c
  group Kalman filter
    ./kalman filter/: kalman.c kalman.h
  group Drivers
    ./Drivers/: stm32f4_spl_spi.c stm32f4_spl_spi.h stm32f4_spl_can.c stm32f4_spl_can.h
